# Keil uVision project Project.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Source\APP;..\Source\BSP;..\Source\STM32F10xLib\inc;..\Source\STM32F10xLib\M3;..\Source\Public;..\Source\USB\lib;..\Source\USB\src;..\Source\Drive;C:\Keil_v5\ARM\PACK\ARM\CMSIS-FreeRTOS\9.0.0\Demo\CORTEX_M4_ATSAM4L_Atmel_Studio\src\asf\thirdparty\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../Source/APP/: Main.c
  group DRIVER
    ../Source/Drive/: delay.c IOI2C.c UART1.c UART2.c
  group Public
    ../Source/Public/: Queue.c
  group FWLib
    ../Source/STM32F10xLib/M3/: system_stm32f10x.c stm32f10x_it.c
    ../Source/STM32F10xLib/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_bkp.c
    ../Source/STM32F10xLib/startup/: startup_stm32f10x_hd.s
  group USB
    ../Source/USB/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_it.c usb_prop.c usb_pwr.c
  group USB/Lib
    ../Source/USB/lib/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group DOC
    ../DOC/: Note.h
software components: CMSIS:CORE 5.0.2
